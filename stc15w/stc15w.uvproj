# Keil uVision project stc15w.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: stc15w +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\eeprom;.\IR;.\uart;.\delay;.\buzzer;.\rtc;.\pw_switch;.\time2
  group IR
    ./IR/: ir_receive.c ir_send.c
  group rtc
    ./rtc/: i2c.c rtc_tcs8563.c
  group led
    ./led/: led.c
  group uart
    ./uart/: uart.c
  group main
    ./: STARTUP.A51 main.c
  group time2
    ./time2/: time2.c
  group delay
    ./delay/: delay.c
  group buzzer
    ./buzzer/: buzzer.c
  group eeprom
    ./eeprom/: eeprom.c
  group algorithm
    ./algorithm/: algorithm.c
  group pw_switch
    ./pw_switch/: pw_switch.c
  group readme
    ./readme/: readme.txt
